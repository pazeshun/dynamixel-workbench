Commit message: wip

File: dynamixel_general_hw/urdf/sample1.urdf (robot description, URDF)
Before this commit: robot sample_robot, 2 links, 1 joints
Joints:
- joint sample_joint: limit lower=-3.1415 upper=3.1415 effort=0 velocity=6.8 -> lower=-1 upper=1 effort=0 velocity=6.8
